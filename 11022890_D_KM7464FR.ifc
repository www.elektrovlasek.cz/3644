Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-17T08:43:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 17 08:43:40 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{ADE09B92-FF5F-41F8-8AF0-6D288E2FE33A}\ifc * Database version: 5507 * Database creation date: Wed Apr 17 08:43:39 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 17 08:43:40 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 17 08:43:40 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 26746400_D_11022890_KM7464FR, 11022890_D_KM7464FR:26746400_D_11022890_KM7464FR:204696
In: Level 1
Type - Classification: A-KM-7000 (Uniformat); Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Design_Stainless Steel, z_Miele_Connection_Electric, Default
Pset_BuildingElementProxyCommon - Reference: 26746400_D_11022890_KM7464FR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
